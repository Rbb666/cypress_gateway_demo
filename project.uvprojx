# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: CY8C624ALQI-S2D42:Cortex-M4 Infineon
  pack: Infineon.PSoC6_DFP.1.4.0
  cpu: IRAM(0x08000000,0x00100000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CY_USING_HAL, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, CORE_NAME_CM0P_0, COMPONENT_CAT1A, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, CY_USING_PREBUILT_CM0P_IMAGE, __RTTHREAD__, COMPONENT_CAT1, CORE_NAME_CM4_0, CY8C624ALQI_S2D42
  c include: rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;packages\pahomqtt-latest\MQTTClient-RT;packages\LVGL-v8.3.5\src\extra\widgets\list;rt-thread\components\net\netdev\include;packages\LVGL-v8.3.5\src\extra\widgets\imgbtn;packages\LVGL-v8.3.5\src\extra\libs\freetype;libraries\IFX_PSOC6_HAL\mtb_shared\usbdev;packages\LVGL-v8.3.5\src\extra\widgets\tabview;packages\LVGL-v8.3.5\src\extra\others\imgfont;applications\lvgl;rt-thread\components\libc\compilers\common\include;packages\LVGL-v8.3.5\src\extra\others\gridnav;packages\LVGL-v8.3.5\src\extra\widgets\win;libraries\IFX_PSOC6_HAL\psoc6cm0p;rt-thread\components\drivers\spi;packages\LVGL-v8.3.5\src\extra\widgets\animimg;rt-thread\components\drivers\wlan;board;packages\LVGL-v8.3.5\src\extra\widgets\msgbox;packages\LVGL-v8.3.5\src\draw\sw;packages\LVGL-v8.3.5\src\extra\layouts\flex;packages\LVGL-v8.3.5\src\extra\widgets;rt-thread\libcpu\arm\cortex-m4;packages\tlsf-latest\src;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\cmsis\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;libs\TARGET_RTT-062S2\config\GeneratedSource;packages\onenet-latest\inc;packages\LVGL-v8.3.5\src\draw\stm32_dma2d;packages\LVGL-v8.3.5\src\extra\widgets\spinner;packages\rw007-latest;packages\LVGL-v8.3.5\src\draw\nxp\pxp;rt-thread\include;packages\LVGL-v8.3.5\env_support\rt-thread\squareline;packages\LVGL-v8.3.5\src\extra\libs\sjpg;packages\rw007-latest\inc;packages\LVGL-v8.3.5\env_support\rt-thread;packages\LVGL-v8.3.5\src\draw;libraries\IFX_PSOC6_HAL\mtb_shared\serial-flash;packages\LVGL-v8.3.5\src\draw\arm2d;packages\LVGL-v8.3.5\src\draw\swm341_dma2d;packages\LVGL-v8.3.5\src\extra\widgets\keyboard;packages\LVGL-v8.3.5\src\extra\themes\default;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include;packages\LVGL-v8.3.5\src\extra\widgets\colorwheel;packages\LVGL-v8.3.5\src\extra\libs;rt-thread\components\dfs\dfs_v1\filesystems\devfs;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1A\include;libs\TARGET_RTT-062S2;rt-thread\components\libc\cplusplus;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\env_support\rt-thread\squareline\ui;rt-thread\components\net\lwip\lwip-2.0.3\src\include;packages\LVGL-v8.3.5\src\extra\libs\ffmpeg;rt-thread\components\net\lwip\port;rt-thread\components\net\sal\include\socket;packages\LVGL-v8.3.5\src\extra\libs\rlottie;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\libs\gif;packages\ili9341-latest;packages\LVGL-v8.3.5\src\core;packages\sht3x-v1.0.0;packages\LVGL-v8.3.5\src\draw\sdl;packages\LVGL-v8.3.5\src\extra\layouts;packages\LVGL-v8.3.5\src\extra\themes\basic;packages\LVGL-v8.3.5\src\extra\widgets\chart;rt-thread\components\net\sal\impl;packages\i2c-tools-v1.0.0;packages\bh1750-v1.0.0;packages\LVGL-v8.3.5\src\extra\widgets\meter;rt-thread\components\finsh;libraries\HAL_Drivers;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\COMPONENT_CAT1A\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;packages\LVGL-v8.3.5\src\font;rt-thread\components\utilities\resource;rt-thread\components\drivers\include;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include_pvt;packages\LVGL-v8.3.5\src\extra\libs\bmp;packages\LVGL-v8.3.5\src;packages\LVGL-v8.3.5\src\extra;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\drivers\include;packages\LVGL-v8.3.5\src\extra\others\msg;packages\LVGL-v8.3.5\src\extra\libs\fsdrv;packages\cJSON-latest;libraries\HAL_Drivers\config;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.5\src\extra\libs\png;packages\LVGL-v8.3.5\src\extra\widgets\led;packages\LVGL-v8.3.5\src\extra\themes\mono;packages\LVGL-v8.3.5\src\extra\others\monkey;packages\LVGL-v8.3.5\src\extra\widgets\spinbox;.;libraries\IFX_PSOC6_HAL\core-lib\include;packages\LVGL-v8.3.5\src\extra\widgets\span;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\stdio;packages\LVGL-v8.3.5\src\extra\widgets\tileview;applications;packages\LVGL-v8.3.5\src\extra\others;libraries\IFX_PSOC6_HAL\capsense;packages\LVGL-v8.3.5\src\misc;rt-thread\components\net\sal\include\socket\sys_socket;packages\LVGL-v8.3.5\src\extra\others\snapshot;rt-thread\components\net\sal\include\dfs_net;packages\LVGL-v8.3.5\src\extra\others\ime;packages\LVGL-v8.3.5\src\extra\widgets\menu;board\ports;rt-thread\components\drivers\include;rt-thread\components\net\sal\include;packages\i2c-tools-v1.0.0\src;packages\LVGL-v8.3.5\src\extra\layouts\grid;packages\LVGL-v8.3.5\src\widgets;libraries\IFX_PSOC6_HAL\mtb_shared\csdidac;packages\LVGL-v8.3.5\src\extra\themes;packages\LVGL-v8.3.5\src\draw\nxp\vglite;packages\LVGL-v8.3.5\src\extra\others\fragment;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\drivers\include;packages\pahomqtt-latest\MQTTPacket\src;packages\LVGL-v8.3.5\src\hal;rt-thread\components\libc\posix\io\poll;packages\LVGL-v8.3.5\src\extra\widgets\calendar;packages\LVGL-v8.3.5\src\extra\libs\qrcode;rt-thread\components\drivers\sensor;libraries\IFX_PSOC6_HAL\retarget-io
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x100000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: Onenet_App.c main.c
  group bh1750
    packages/bh1750-v1.0.0/: bh1750.c
  group cJSON
    packages/cJSON-latest/: cJSON_Utils.c cJSON.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPlusPlus
    rt-thread/components/libc/cplusplus/: cxx_crt_init.c cxx_crt.cpp cxx_Thread.cpp cxx_Semaphore.cpp cxx_Mutex.cpp
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/sensor/: sensor.c sensor_cmd.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/: board.c
    board/ports/: drv_rw007.c slider_sample.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.S
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_pwm.c drv_spi.c drv_uart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group i2c-tools
    packages/i2c-tools-v1.0.0/src/: i2c_tools.cpp i2c_utils.cpp
  group ili9341
    packages/ili9341-latest/: lcd_ili9341.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/IFX_PSOC6_HAL/capsense/: cy_capsense_csd_v2.c cy_capsense_filter.c cy_capsense_centroid.c cy_capsense_structure.c cy_capsense_sensing.c cy_capsense_tuner.c cy_capsense_sensing_v2.c cy_capsense_csx_v2.c cy_capsense_processing.c cy_capsense_control.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/triggers/: cyhal_triggers_psoc6_02.c
    libraries/IFX_PSOC6_HAL/retarget-io/: cy_retarget_io.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/: cy_scb_i2c.c cy_gpio.c cy_tcpwm_counter.c cy_scb_uart.c cy_scb_common.c cy_ipc_sema.c cy_ipc_drv.c cy_syslib.c cy_ipc_pipe.c cy_tcpwm_pwm.c cy_scb_spi.c cy_prot.c cy_mcwdt.c cy_sysclk.c cy_sysint.c cy_systick.c cy_trigmux.c cy_csd.c cy_syspm.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/source/: cyhal_irq_impl.c cyhal_scb_common.c cyhal_clock.c cyhal_utils_impl.c cyhal_gpio.c cyhal_system.c cyhal_utils.c cyhal_timer.c cyhal_pwm.c cyhal_i2c.c cyhal_hwmgr.c cyhal_lptimer.c cyhal_syspm.c cyhal_interconnect.c cyhal_spi.c cyhal_tcpwm_common.c cyhal_uart.c
    libraries/IFX_PSOC6_HAL/psoc6cm0p/COMPONENT_CM0P_SLEEP/: psoc6_03_cm0p_sleep.c psoc6_01_cm0p_sleep.c psoc6_04_cm0p_sleep.c psoc6_02_cm0p_sleep.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/pin_packages/: cyhal_psoc6_02_68_qfn.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/devices/COMPONENT_CAT1A/source/: cy_device.c
    libraries/IFX_PSOC6_HAL/lib/: cy_capsense.lib
  group libs
    libs/TARGET_RTT-062S2/config/GeneratedSource/: cycfg_routing.c cycfg_clocks.c cycfg_system.c cycfg_pins.c cycfg_capsense.c cycfg.c cycfg_peripherals.c cycfg_qspi_memslot.c
    libs/TARGET_RTT-062S2/: cybsp.c
    libs/TARGET_RTT-062S2/COMPONENT_CM4/TOOLCHAIN_ARM/: startup_psoc6_02_cm4.S
    libs/TARGET_RTT-062S2/COMPONENT_CM4/: system_psoc6_cm4.c
  group LVGL
    packages/LVGL-v8.3.5/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.5/src/draw/sdl/: lv_draw_sdl_img.c lv_draw_sdl_mask.c lv_draw_sdl.c lv_draw_sdl_stack_blur.c lv_draw_sdl_arc.c lv_draw_sdl_line.c lv_draw_sdl_layer.c lv_draw_sdl_composite.c lv_draw_sdl_label.c lv_draw_sdl_bg.c lv_draw_sdl_rect.c lv_draw_sdl_utils.c lv_draw_sdl_texture_cache.c lv_draw_sdl_polygon.c
    packages/LVGL-v8.3.5/src/core/: lv_disp.c lv_obj_class.c lv_obj_style_gen.c lv_obj_tree.c lv_obj_pos.c lv_event.c lv_theme.c lv_group.c lv_obj_scroll.c lv_indev.c lv_obj_style.c lv_indev_scroll.c lv_obj.c lv_obj_draw.c lv_refr.c
    packages/LVGL-v8.3.5/src/draw/: lv_draw_rect.c lv_draw_img.c lv_draw_mask.c lv_draw_arc.c lv_img_cache.c lv_draw_transform.c lv_img_buf.c lv_img_decoder.c lv_draw_triangle.c lv_draw_line.c lv_draw_layer.c lv_draw.c lv_draw_label.c
    packages/LVGL-v8.3.5/src/font/: lv_font_montserrat_40.c lv_font_montserrat_24.c lv_font_montserrat_16.c lv_font_montserrat_28.c lv_font.c lv_font_montserrat_42.c lv_font_montserrat_14.c lv_font_montserrat_44.c lv_font_montserrat_28_compressed.c lv_font_montserrat_46.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_48.c lv_font_unscii_16.c lv_font_montserrat_32.c lv_font_fmt_txt.c lv_font_montserrat_18.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_22.c lv_font_unscii_8.c lv_font_montserrat_12.c lv_font_montserrat_30.c lv_font_montserrat_26.c lv_font_montserrat_38.c lv_font_simsun_16_cjk.c lv_font_montserrat_20.c lv_font_montserrat_12_subpx.c
    packages/LVGL-v8.3.5/src/hal/: lv_hal_tick.c lv_hal_indev.c lv_hal_disp.c
    packages/LVGL-v8.3.5/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.5/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.5/src/draw/sw/: lv_draw_sw_transform.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_letter.c lv_draw_sw_blend.c lv_draw_sw_layer.c lv_draw_sw_gradient.c lv_draw_sw_dither.c lv_draw_sw_polygon.c lv_draw_sw_line.c lv_draw_sw_img.c lv_draw_sw_rect.c
    packages/LVGL-v8.3.5/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    packages/LVGL-v8.3.5/src/extra/: lv_extra.c
    packages/LVGL-v8.3.5/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.5/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.5/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.5/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.5/src/misc/: lv_area.c lv_async.c lv_mem.c lv_ll.c lv_fs.c lv_utils.c lv_lru.c lv_color.c lv_txt.c lv_printf.c lv_txt_ap.c lv_anim.c lv_style.c lv_bidi.c lv_math.c lv_style_gen.c lv_templ.c lv_tlsf.c lv_anim_timeline.c lv_log.c lv_timer.c lv_gc.c
    packages/LVGL-v8.3.5/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.5/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.5/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.5/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.5/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.5/src/widgets/: lv_objx_templ.c lv_arc.c lv_btn.c lv_line.c lv_slider.c lv_dropdown.c lv_switch.c lv_bar.c lv_img.c lv_roller.c lv_table.c lv_canvas.c lv_btnmatrix.c lv_label.c lv_checkbox.c lv_textarea.c
    packages/LVGL-v8.3.5/src/extra/libs/fsdrv/: lv_fs_posix.c lv_fs_win32.c lv_fs_fatfs.c lv_fs_stdio.c
    packages/LVGL-v8.3.5/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.5/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.5/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_rect.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_vglite_buf.c lv_vglite_utils.c lv_draw_vglite.c
    packages/LVGL-v8.3.5/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.5/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.5/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.5/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.5/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.5/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.5/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.5/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.5/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.5/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.5/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.5/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.5/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.5/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.5/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.5/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.5/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.5/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.5/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.5/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.5/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.5/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.5/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.5/src/extra/widgets/msgbox/: lv_msgbox.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.5/env_support/rt-thread/: lv_rt_thread_port.c
  group LVGL-SquareLine
    packages/LVGL-v8.3.5/env_support/rt-thread/squareline/: lv_ui_entry.c
    packages/LVGL-v8.3.5/env_support/rt-thread/squareline/ui/: ui_img_img_btn_off_png.c ui_img_img_slider_png.c ui.c ui_font_Big_Number.c ui_img_img_btn_bg_png.c ui_img_wifi_png.c ui_font_Bold_Font.c ui_Medical_Screen.c ui_helpers.c ui_img_wave2_png.c ui_img_img_line_png.c ui_img_wave1_png.c ui_img_img_btn_on_png.c ui_events.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group onenet
    packages/onenet-latest/src/: onenet_mqtt.c
    packages/onenet-latest/samples/: onenet_sample.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTSerializePublish.c MQTTConnectClient.c MQTTSubscribeServer.c MQTTFormat.c MQTTSubscribeClient.c MQTTUnsubscribeServer.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTPacket.c MQTTUnsubscribeClient.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rw007
    packages/rw007-latest/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group sht3x
    packages/sht3x-v1.0.0/: sht3x.c
  group tlsf
    packages/tlsf-latest/src/: tlsf.c
    packages/tlsf-latest/: rt_tlsf.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
